FILESEXTRAPATHS_append := ":${THISDIR}/libart-lgpl"
