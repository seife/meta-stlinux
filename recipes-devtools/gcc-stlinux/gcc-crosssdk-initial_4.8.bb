require recipes-devtools/gcc-stlinux/gcc-cross-initial_${PV}.bb
require gcc-crosssdk-initial.inc

