require recipes-devtools/gcc-stlinux/gcc-cross_${PV}.bb
require gcc-cross-initial.inc
