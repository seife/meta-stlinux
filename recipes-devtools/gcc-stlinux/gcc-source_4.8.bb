require recipes-devtools/gcc-stlinux/gcc-stlinux-${PV}.inc
require recipes-devtools/gcc-stlinux/gcc-source.inc
