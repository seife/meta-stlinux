require recipes-devtools/gcc-stlinux/gcc-stlinux-${PV}.inc
require libgcc.inc
