require recipes-devtools/gcc-stlinux/gcc-cross_${PV}.bb
require gcc-crosssdk.inc
