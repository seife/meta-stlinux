require recipes-devtools/gcc-stlinux/gcc-stlinux-${PV}.inc
require gcc-cross.inc

